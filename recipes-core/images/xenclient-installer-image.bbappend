FILESEXTRAPATHS_prepend := "${THISDIR}/xenclient-installer-image:"
PR .= ".7"
