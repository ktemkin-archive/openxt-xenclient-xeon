#This enables our surfman.conf to override the default surfman.conf.
EXTRAPATHS_prepend := "${THISDIR}/surfman"
PR += ".0"
